options:
  parameters:
    author: loved
    generate_options: no_gui
    id: lora_monitor
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw_lora
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: ds_rate_lora
  id: variable
  parameters:
    value: int(samp_rate/bw_lora)
  states: {}
- name: fc
  id: variable
  parameters:
    value: 908.6e6
  states: {}
- name: filename_hex
  id: variable
  parameters:
    value: '"/home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 13e6+0*250e3 + 0*56e6/256
  states: {}
- name: samp_rate_lora
  id: variable
  parameters:
    value: int(samp_rate/ds_rate_lora)
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-65'
  states: {}
- name: usrp_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: LoRa_AIS_reportPower_0
  id: LoRa_AIS_reportPower
  parameters:
    channel_tag: Channel 1 Magnitude
  states: {}
- name: LoRa_AIS_reportPower_0_0
  id: LoRa_AIS_reportPower
  parameters:
    channel_tag: Channel 2 Magnitude
  states: {}
- name: LoRa_AIS_reportPower_0_0_0
  id: LoRa_AIS_reportPower
  parameters:
    channel_tag: Channel 3 Magnitude
  states: {}
- name: LoRa_AIS_reportPower_0_0_0_0
  id: LoRa_AIS_reportPower
  parameters:
    channel_tag: Channel 4 Magnitude
  states: {}
- name: LoRa_AIS_reportPower_0_0_0_0_0
  id: LoRa_AIS_reportPower
  parameters:
    channel_tag: Channel 8 Magnitude
  states: {}
- name: LoRa_AIS_reportPower_0_0_0_1
  id: LoRa_AIS_reportPower
  parameters:
    channel_tag: Channel 7 Magnitude
  states: {}
- name: LoRa_AIS_reportPower_0_0_1
  id: LoRa_AIS_reportPower
  parameters:
    channel_tag: Channel 6 Magnitude
  states: {}
- name: LoRa_AIS_reportPower_0_1
  id: LoRa_AIS_reportPower
  parameters:
    channel_tag: Channel 5 Magnitude
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_1_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_2
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_2_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_2_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_2_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_2_0_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_2_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/loved/Projects/loved2024/iot_living_lab/KENNEL/monitor_output/monitor_output.hex
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: fc-902.3e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: fc-902.5e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: fc-902.9e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: fc-903.7e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0_1
  id: blocks_freqshift_cc
  parameters:
    freq: fc-903.3e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_1
  id: blocks_freqshift_cc
  parameters:
    freq: fc-902.7e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_1_0
  id: blocks_freqshift_cc
  parameters:
    freq: fc-903.5e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_2
  id: blocks_freqshift_cc
  parameters:
    freq: fc-903.1e6
    sample_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from time import strftime
  states: {}
- name: lora_rx_0_0_1_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate_lora
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_1_0_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate_lora
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_1_0_0_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate_lora
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_1_0_0_0_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate_lora
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_1_0_0_1
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate_lora
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_1_0_1
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate_lora
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_1_0_1_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate_lora
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_1_0_2
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate_lora
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: ds_rate_lora
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: ds_rate_lora
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: ds_rate_lora
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: ds_rate_lora
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: ds_rate_lora
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: ds_rate_lora
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: ds_rate_lora
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: ds_rate_lora
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '45000'
    win: window.WIN_HAMMING
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    dev_addr: ''
    gain0: usrp_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0_0, '0', LoRa_AIS_reportPower_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', lora_rx_0_0_1_0, '0']
- [analog_pwr_squelch_xx_0_0_0, '0', LoRa_AIS_reportPower_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0, '0', lora_rx_0_0_1_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0_0, '0', LoRa_AIS_reportPower_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0_0, '0', lora_rx_0_0_1_0_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0_0_0, '0', LoRa_AIS_reportPower_0_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0_0_0, '0', lora_rx_0_0_1_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0_1, '0', LoRa_AIS_reportPower_0_0_1, '0']
- [analog_pwr_squelch_xx_0_0_0_1, '0', lora_rx_0_0_1_0_0_1, '0']
- [analog_pwr_squelch_xx_0_0_1, '0', LoRa_AIS_reportPower_0_0_0, '0']
- [analog_pwr_squelch_xx_0_0_1, '0', lora_rx_0_0_1_0_1, '0']
- [analog_pwr_squelch_xx_0_0_1_0, '0', LoRa_AIS_reportPower_0_0_0_1, '0']
- [analog_pwr_squelch_xx_0_0_1_0, '0', lora_rx_0_0_1_0_1_0, '0']
- [analog_pwr_squelch_xx_0_0_2, '0', LoRa_AIS_reportPower_0_1, '0']
- [analog_pwr_squelch_xx_0_0_2, '0', lora_rx_0_0_1_0_2, '0']
- [blocks_freqshift_cc_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_freqshift_cc_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_freqshift_cc_0_0_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [blocks_freqshift_cc_0_0_0_0_0, '0', low_pass_filter_0_0_0_0_0, '0']
- [blocks_freqshift_cc_0_0_0_1, '0', low_pass_filter_0_0_0_1, '0']
- [blocks_freqshift_cc_0_0_1, '0', low_pass_filter_0_0_1, '0']
- [blocks_freqshift_cc_0_0_1_0, '0', low_pass_filter_0_0_1_0, '0']
- [blocks_freqshift_cc_0_0_2, '0', low_pass_filter_0_0_2, '0']
- [lora_rx_0_0_1_0, '0', blocks_file_sink_0, '0']
- [lora_rx_0_0_1_0_0, '0', blocks_file_sink_0_2, '0']
- [lora_rx_0_0_1_0_0_0, '0', blocks_file_sink_0_2_0_0, '0']
- [lora_rx_0_0_1_0_0_0_0, '0', blocks_file_sink_0_2_0_0_0, '0']
- [lora_rx_0_0_1_0_0_1, '0', blocks_file_sink_0_2_1, '0']
- [lora_rx_0_0_1_0_1, '0', blocks_file_sink_0_2_0, '0']
- [lora_rx_0_0_1_0_1_0, '0', blocks_file_sink_0_2_0_1, '0']
- [lora_rx_0_0_1_0_2, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_0_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [low_pass_filter_0_0_0, '0', analog_pwr_squelch_xx_0_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', analog_pwr_squelch_xx_0_0_0_0, '0']
- [low_pass_filter_0_0_0_0_0, '0', analog_pwr_squelch_xx_0_0_0_0_0, '0']
- [low_pass_filter_0_0_0_1, '0', analog_pwr_squelch_xx_0_0_0_1, '0']
- [low_pass_filter_0_0_1, '0', analog_pwr_squelch_xx_0_0_1, '0']
- [low_pass_filter_0_0_1_0, '0', analog_pwr_squelch_xx_0_0_1_0, '0']
- [low_pass_filter_0_0_2, '0', analog_pwr_squelch_xx_0_0_2, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
