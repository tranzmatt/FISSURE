options:
  parameters:
    generate_options: no_gui
    id: lfm_beacon_rtlsdr
    output_language: python
  states: {}

blocks:
- name: Nmatch
  id: variable
  parameters:
    value: int(0.25 * ton * samp_rate)
  states: {}
- name: avg_len
  id: variable
  parameters:
    value: int(0.01*samp_rate)
  states: {}
- name: bw
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: eps
  id: variable
  parameters:
    value: '1e-12'
  states: {}
- name: holdoff_s
  id: variable
  parameters:
    value: '0.08'
  states: {}
- name: lpf_cutoff
  id: variable
  parameters:
    value: bw*1.2
  states: {}
- name: lpf_trans
  id: variable
  parameters:
    value: bw/2
  states: {}
- name: matched_taps
  id: variable
  parameters:
    value: np.conjugate(np.exp(1j*2*np.pi*np.cumsum(((-bw/2)+(bw/ton)*(np.arange(Nmatch)/samp_rate)))/samp_rate)[::-1])
  states: {}
- name: min_peak
  id: variable
  parameters:
    value: '40'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Transmits an on message for a Monoprice Z-Wave Plus RGB Smart Bulb."'
  states: {}
- name: peak_window
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '30'
  states: {}
- name: ton
  id: variable
  parameters:
    value: '10e-3'
  states: {}
- name: tperiod
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: xlating_hz
  id: variable
  parameters:
    value: '-150e3'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: eps
    type: float
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '4000'
    scale: 1/avg_len
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '64'
    max_iter: '4000'
    scale: 1/64
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import time
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(
              self,
              samp_rate=1e6,
              rx_freq_hz=433e6,
              tperiod=0.1,
              thresh=10.0,
              min_peak=12.0,
              holdoff_s=0.08,
              peak_window=8000,
          ):
              gr.sync_block.__init__(
                  self,
                  name='burst_detector',
                  in_sig=[np.float32],
                  out_sig=None
              )

              self.samp_rate = float(samp_rate)
              self.rx_freq_hz = float(rx_freq_hz)
              self.thresh = float(thresh)
              self.min_peak = float(min_peak)
              self.holdoff = int(float(holdoff_s) * self.samp_rate)
              self.peak_window = int(peak_window)

              self.n = 0
              self.next_ok = 0
              self.in_peak = False
              self.peak_val = 0.0
              self.peak_idx = 0
              self.peak_end = 0

              self.message_port_register_out(pmt.intern("det"))

          def set_rx_freq_hz(self, rx_freq_hz):
              self.rx_freq_hz = float(rx_freq_hz)

          def work(self, input_items, output_items):
              x = input_items[0]
              L = len(x)

              for i in range(L):
                  idx = self.n + i
                  v = float(x[i])

                  if idx < self.next_ok:
                      continue

                  if not self.in_peak:
                      if v >= self.thresh:
                          self.in_peak = True
                          self.peak_val = v
                          self.peak_idx = idx
                          self.peak_end = idx + self.peak_window
                  else:
                      if v > self.peak_val:
                          self.peak_val = v
                          self.peak_idx = idx

                      if idx >= self.peak_end:
                          if self.peak_val >= self.min_peak:
                              ts = time.time()
                              msg = f"TSI:/LFM Beacon/{self.rx_freq_hz:.1f}/{self.peak_val:.2f}/{ts:.6f}"
                              self.message_port_pub(
                                  pmt.intern("det"),
                                  pmt.intern(msg)
                              )

                          self.next_ok = self.peak_end + self.holdoff
                          self.in_peak = False

              self.n += L
              return L
    holdoff_s: holdoff_s
    min_peak: min_peak
    peak_window: peak_window
    rx_freq_hz: rx_freq
    samp_rate: samp_rate
    thresh: threshold
    tperiod: tperiod
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlating_hz
    decim: '1'
    samp_rate: samp_rate
    taps: matched_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '300000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '300000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '300000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rx_freq
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_divide_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0_0_0_1_0, '0']
- [blocks_moving_average_xx_1, '0', epy_block_0, '0']
- [blocks_moving_average_xx_1, '0', qtgui_time_sink_x_0_0_0_1_0_0, '0']
- [dc_blocker_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [epy_block_0, det, blocks_message_debug_0, print]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_rtlsdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
