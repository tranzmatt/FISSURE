options:
  parameters:
    generate_options: qt_gui
    id: antenna_test_rx
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label0: '915'
    label1: '2412'
    label2: '5800'
    num_opts: '3'
    option0: '915000000'
    option1: '2412000000'
    option2: '5800000000'
    type: int
    value: '2412000000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 100e6
    step: 10e6
    stop: 6000e6
    value: 900e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-90'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '70'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
